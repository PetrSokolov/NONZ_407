# Keil uVision project no_nz.uvprojx, settings and files
target no_nz Configuration (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: no_nz Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_adc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: Retarget.c stm32f4xx_hal_msp.c dma.c gpio.c tim.c adc.c spi.c main.cpp stm32f4xx_it.cpp
  group Objects Definitions
    ../Src/_Objects_Definitions/: ObjectsDefinitions.cpp
  group Main Loop
    ../Src/_Main_Loop/: Main_Loop.cpp
  group ADC
    ../Src/_ADC/: ADC.cpp
  group Menu Items
    ../Src/_Menu_Items/: Engine.cpp Editor.cpp Parameters.cpp MainMenu.cpp DisplayLedDecoder.cpp DisplayLed4Digit.cpp
  group Analog Sensors
    ../Src/_AnalogSensors/: AnalogSensors.cpp
  group DSP Tools
    ../Src/_DSP_tools/: Filters.cpp
  group PWM
    ../Src/_PWM/: PWM.cpp PWM_User.cpp
  group RC
    ../Src/_RC/: RC.cpp RC_Decoder.cpp
